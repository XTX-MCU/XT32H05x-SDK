# Keil uVision project xt32h0xx_App_advtim_pwm_dma.uvprojx, settings and files
target xt32h0xx_App_AdvTimPWMdma (6160000::V6.16::ARMCLANG)
  device: XT32H053 XTX
  pack: XTX.XT32H0.1.0.0
  cpu: IRAM(0x20000000,0x4000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: xt32h0xx_App_AdvTim_pwmDma +hex
  AfterMake: ..\Tools\output_image.bat  xt32h0xx_App_AdvTim_pwmDma
  c flags: Optim=1 OneElfS=1 v6Lang=3 v6LangP=3 wLevel=1
  c define: USE_HAL_DRIVER,XT32H0xxB
  c include: ../Inc;../../../../../../Drivers/CMSIS/Device/XTX/XT32H0xx/Include;../../../../../../Drivers/XT32H0xx_HAL_Driver/Inc
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x4000
  group User
    ../src/: main.c timeratask.c dmamemtask.c gpiotask.c xt32h0xx_hal_msp.c xt32h0xx_it.c
  group CMSIS
    ../src/: system_xt32h0xx.c
  group XT32H0xx_HAL_Driver
    ../../../../../../Drivers/XT32H0xx_HAL_Driver/Src/: xt32h0xx_hal.c xt32h0xx_hal_cortex.c xt32h0xx_hal_ictl.c xt32h0xx_hal_padi.c xt32h0xx_hal_rcc.c xt32h0xx_hal_gpio.c xt32h0xx_hal_tim.c xt32h0xx_hal_tim_ex.c xt32h0xx_hal_tim_port.c xt32h0xx_hal_dma.c
  group MDK_ARM
    ./: startup_xt32h0xxb.s
software components: CMSIS:CORE 5.6.0
